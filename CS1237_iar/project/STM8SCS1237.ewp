# IAR project STM8SCS1237.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8SCS1237.hex
  ILINK.IlinkOutputFile: STM8SCS1237.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    ../FWlib/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
  group USER
    ../USER/: cs1237.c cs1237.h main.c readme.txt stm8s_conf.h stm8s_it.c stm8s_it.h timer1.c timer1.h uart1.c uart1.h wwdg.c wwdg.h
